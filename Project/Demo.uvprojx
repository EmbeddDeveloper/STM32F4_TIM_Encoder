# Keil uVision project Demo.uvprojx, settings and files
target STM32F429VE (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F429_439xx
  c include: ..\App;..\Bsp;..\Libraries\CMSIS\CoreSupport;..\Libraries\CMSIS\DeviceSupport;..\Libraries\STM32F4xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../Libraries/CMSIS/DeviceSupport/startup/: startup_stm32f429_439xx.s
    ../Libraries/CMSIS/DeviceSupport/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c
  group Bsp
    ../Bsp/: bsp.c bsp_timer.c bsp_usart.c
  group App
    ../App/: main.c stm32f4xx_it.c
  group Doc
    ../Doc/: ReadMe.txt
target STM32F429ZE (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: as above
  output: Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F429_439xx
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
target STM32F429IE (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429IETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: as above
  output: Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F429_439xx
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
target STM32F429BE (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429BETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: as above
  output: Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F429_439xx
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
target STM32F429NE (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429NEHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: as above
  output: Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F429_439xx
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
target STM32F429VG (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F429_439xx
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
target STM32F429ZG (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: as above
  output: Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F429_439xx
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
target STM32F429AG (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429AGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: as above
  output: Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F429_439xx
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
target STM32F429IG (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: as above
  output: Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F429_439xx
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
target STM32F429BG (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429BGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: as above
  output: Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F429_439xx
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
target STM32F429NG (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429NGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: as above
  output: Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F429_439xx
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
target STM32F429VI (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F429_439xx
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
target STM32F429ZI (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: as above
  output: Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F429_439xx
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
target STM32F429AI (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429AIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: as above
  output: Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F429_439xx
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
target STM32F429II (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: as above
  output: Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F429_439xx
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
target STM32F429BI (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: as above
  output: Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F429_439xx
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
target STM32F429NI (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: as above
  output: Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F429_439xx
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
